<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sync_RDF_N210</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gan</value></param>
<param><key>value</key><value>60</value></param>
<param><key>label</key><value>Ganancia</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>400e6</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value6</key><value>"/tmp"</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>Gain</value></param>
<param><key>field4</key><value>NumArrayElements</value></param>
<param><key>field5</key><value>RxAddr</value></param>
<param><key>field6</key><value>DirectoryConfigFiles</value></param>
<param><key>field7</key><value>RelativePhaseOffsets</value></param>
<param><key>value3</key><value>60</value></param>
<param><key>value4</key><value>2</value></param>
<param><key>value7</key><value>"relative_phase_offsets_245.cfg"</value></param>
<param><key>value5</key><value>"addr0=192.168.10.2,addr1=192.168.10.3"</value></param>
<param><key>value0</key><value>200e3</value></param>
<param><key>value1</key><value>10e3</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-360</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>360</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>rel_phase_offsets_file_name</value></param>
<param><key>num_ports</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value>Channel #0: Real</value></param>
<param><key>color10</key><value>"blue"</value></param>
<param><key>label10</key><value></value></param>
<param><key>color2</key><value>"dark green"</value></param>
<param><key>label2</key><value>Channel #0: Imag</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>Channel #1: Real</value></param>
<param><key>color4</key><value>"Dark Blue"</value></param>
<param><key>label4</key><value>Channel #1: Imag</value></param>
<param><key>color5</key><value>"red"</value></param>
<param><key>label5</key><value>Channel #2: Real</value></param>
<param><key>color6</key><value>"dark red"</value></param>
<param><key>label6</key><value>Channel #2: Imag</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value>Channel #3: Real</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value>Channel #3: Imag</value></param>
<param><key>color9</key><value>"dark green"</value></param>
<param><key>label9</key><value></value></param>
<param><key>nconnections</key><value>input_variables.NumArrayElements</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>input_variables.SampleRate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
</block>
<block>
<key>syncro_phase_offset</key>
<param><key>id</key><value>syncro_phase_offset_0</value></param>
<param><key>angle</key><value>offset</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>input_variables.Gain</value></param>
<param><key>ant10</key><value></value></param>
<param><key>dc_offs_enb10</key><value>""</value></param>
<param><key>iq_imbal_enb10</key><value>""</value></param>
<param><key>norm_gain10</key><value>False</value></param>
<param><key>ant11</key><value></value></param>
<param><key>dc_offs_enb11</key><value>""</value></param>
<param><key>iq_imbal_enb11</key><value>""</value></param>
<param><key>norm_gain11</key><value>False</value></param>
<param><key>ant12</key><value></value></param>
<param><key>dc_offs_enb12</key><value>""</value></param>
<param><key>iq_imbal_enb12</key><value>""</value></param>
<param><key>norm_gain12</key><value>False</value></param>
<param><key>ant13</key><value></value></param>
<param><key>dc_offs_enb13</key><value>""</value></param>
<param><key>iq_imbal_enb13</key><value>""</value></param>
<param><key>norm_gain13</key><value>False</value></param>
<param><key>ant14</key><value></value></param>
<param><key>dc_offs_enb14</key><value>""</value></param>
<param><key>iq_imbal_enb14</key><value>""</value></param>
<param><key>norm_gain14</key><value>False</value></param>
<param><key>ant15</key><value></value></param>
<param><key>dc_offs_enb15</key><value>""</value></param>
<param><key>iq_imbal_enb15</key><value>""</value></param>
<param><key>norm_gain15</key><value>False</value></param>
<param><key>ant16</key><value></value></param>
<param><key>dc_offs_enb16</key><value>""</value></param>
<param><key>iq_imbal_enb16</key><value>""</value></param>
<param><key>norm_gain16</key><value>False</value></param>
<param><key>ant17</key><value></value></param>
<param><key>dc_offs_enb17</key><value>""</value></param>
<param><key>iq_imbal_enb17</key><value>""</value></param>
<param><key>norm_gain17</key><value>False</value></param>
<param><key>ant18</key><value></value></param>
<param><key>dc_offs_enb18</key><value>""</value></param>
<param><key>iq_imbal_enb18</key><value>""</value></param>
<param><key>norm_gain18</key><value>False</value></param>
<param><key>ant19</key><value></value></param>
<param><key>dc_offs_enb19</key><value>""</value></param>
<param><key>iq_imbal_enb19</key><value>""</value></param>
<param><key>norm_gain19</key><value>False</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>gan</value></param>
<param><key>ant20</key><value></value></param>
<param><key>dc_offs_enb20</key><value>""</value></param>
<param><key>iq_imbal_enb20</key><value>""</value></param>
<param><key>norm_gain20</key><value>False</value></param>
<param><key>ant21</key><value></value></param>
<param><key>dc_offs_enb21</key><value>""</value></param>
<param><key>iq_imbal_enb21</key><value>""</value></param>
<param><key>norm_gain21</key><value>False</value></param>
<param><key>ant22</key><value></value></param>
<param><key>dc_offs_enb22</key><value>""</value></param>
<param><key>iq_imbal_enb22</key><value>""</value></param>
<param><key>norm_gain22</key><value>False</value></param>
<param><key>ant23</key><value></value></param>
<param><key>dc_offs_enb23</key><value>""</value></param>
<param><key>iq_imbal_enb23</key><value>""</value></param>
<param><key>norm_gain23</key><value>False</value></param>
<param><key>ant24</key><value></value></param>
<param><key>dc_offs_enb24</key><value>""</value></param>
<param><key>iq_imbal_enb24</key><value>""</value></param>
<param><key>norm_gain24</key><value>False</value></param>
<param><key>ant25</key><value></value></param>
<param><key>dc_offs_enb25</key><value>""</value></param>
<param><key>iq_imbal_enb25</key><value>""</value></param>
<param><key>norm_gain25</key><value>False</value></param>
<param><key>ant26</key><value></value></param>
<param><key>dc_offs_enb26</key><value>""</value></param>
<param><key>iq_imbal_enb26</key><value>""</value></param>
<param><key>norm_gain26</key><value>False</value></param>
<param><key>ant27</key><value></value></param>
<param><key>dc_offs_enb27</key><value>""</value></param>
<param><key>iq_imbal_enb27</key><value>""</value></param>
<param><key>norm_gain27</key><value>False</value></param>
<param><key>ant28</key><value></value></param>
<param><key>dc_offs_enb28</key><value>""</value></param>
<param><key>iq_imbal_enb28</key><value>""</value></param>
<param><key>norm_gain28</key><value>False</value></param>
<param><key>ant29</key><value></value></param>
<param><key>dc_offs_enb29</key><value>""</value></param>
<param><key>iq_imbal_enb29</key><value>""</value></param>
<param><key>norm_gain29</key><value>False</value></param>
<param><key>ant2</key><value>RX2</value></param>
<param><key>center_freq2</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>input_variables.Gain</value></param>
<param><key>ant30</key><value></value></param>
<param><key>dc_offs_enb30</key><value>""</value></param>
<param><key>iq_imbal_enb30</key><value>""</value></param>
<param><key>norm_gain30</key><value>False</value></param>
<param><key>ant31</key><value></value></param>
<param><key>dc_offs_enb31</key><value>""</value></param>
<param><key>iq_imbal_enb31</key><value>""</value></param>
<param><key>norm_gain31</key><value>False</value></param>
<param><key>ant3</key><value>RX2</value></param>
<param><key>center_freq3</key><value>input_variables.CenterFreq</value></param>
<param><key>dc_offs_enb3</key><value>""</value></param>
<param><key>iq_imbal_enb3</key><value>""</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>input_variables.Gain</value></param>
<param><key>ant4</key><value></value></param>
<param><key>dc_offs_enb4</key><value>""</value></param>
<param><key>iq_imbal_enb4</key><value>""</value></param>
<param><key>norm_gain4</key><value>False</value></param>
<param><key>ant5</key><value></value></param>
<param><key>dc_offs_enb5</key><value>""</value></param>
<param><key>iq_imbal_enb5</key><value>""</value></param>
<param><key>norm_gain5</key><value>False</value></param>
<param><key>ant6</key><value></value></param>
<param><key>dc_offs_enb6</key><value>""</value></param>
<param><key>iq_imbal_enb6</key><value>""</value></param>
<param><key>norm_gain6</key><value>False</value></param>
<param><key>ant7</key><value></value></param>
<param><key>dc_offs_enb7</key><value>""</value></param>
<param><key>iq_imbal_enb7</key><value>""</value></param>
<param><key>norm_gain7</key><value>False</value></param>
<param><key>ant8</key><value></value></param>
<param><key>dc_offs_enb8</key><value>""</value></param>
<param><key>iq_imbal_enb8</key><value>""</value></param>
<param><key>norm_gain8</key><value>False</value></param>
<param><key>ant9</key><value></value></param>
<param><key>dc_offs_enb9</key><value>""</value></param>
<param><key>iq_imbal_enb9</key><value>""</value></param>
<param><key>norm_gain9</key><value>False</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>input_variables.RxAddr</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source1</key><value>mimo</value></param>
<param><key>time_source1</key><value>mimo</value></param>
<param><key>nchan</key><value>input_variables.NumArrayElements</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>syncro_phase_offset_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>syncro_phase_offset_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
